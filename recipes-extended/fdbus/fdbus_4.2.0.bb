SUMMARY = "fdbus"
SECTION = "libs"
DESCRIPTION = "The Fast Distributed Bus - version 4.2.0"
LICENSE = "MIT | Apache-2.0"
LIC_FILES_CHKSUM = "file://../doc/authors.rst;md5=f98eedec5926898371fffce386a5040f"
SRC_URI = "git://gitee.com/jeremyczhen/fdbus.git;branch=v4.2.0-release;protocol=https"
SRCREV = "74a6ff42ff64be7513b50a593ca23843f74b08c1"

require fdbus.inc
