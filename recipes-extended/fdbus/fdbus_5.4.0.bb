SUMMARY = "fdbus"
SECTION = "libs"
DESCRIPTION = "The Fast Distributed Bus - version 5.4.0"
LICENSE = "MIT | Apache-2.0"
LIC_FILES_CHKSUM = "file://../doc/authors.rst;md5=f98eedec5926898371fffce386a5040f"
SRC_URI = "git://gitee.com/jeremyczhen/fdbus.git;tag=v5.4.0;protocol=https"

require fdbus.inc
