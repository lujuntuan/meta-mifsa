LICENSE ?= "MIT | MIFSA-LICENSE-1.0"
LIC_FILES_CHKSUM ?= "file://${MIFSA_LAYERDIR}/licenses/MIFSA-LICENSE-1.0;md5=04026fa0bcdc69bf6b9e72d6c96e25ae"
