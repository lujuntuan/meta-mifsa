MIFSA_SRC = "mifsa-gnss"

require mifsa-modules.inc

SYSTEMD_AUTO_ENABLE_${PN} = "enable"
