SRC_URI_append += "file://fragment.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
